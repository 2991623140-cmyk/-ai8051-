# Keil uVision project Piano_AI8051U.uvproj, settings and files
target Piano AI8051U (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(40000000)
  output: Piano_AI8051U +hex
  asm include: .
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: isr.asm main.c song.c audio.c input.c oled.c usb_debug.c
    ./lib/: stc_usb_cdc_32g.lib
